#Note: Mention Each package in individual line
#      cascaded representation with line breaks are not valid in this file.
IMAGE_INSTALL_append = " peekpoke"
IMAGE_INSTALL_append = " gpio-demo"
IMAGE_INSTALL_append = " ia6270-testmod"
IMAGE_INSTALL_append = " ia6270-testapp"
IMAGE_INSTALL_append = " ia6270-ser"
IMAGE_INSTALL_append = " sil9293"
IMAGE_INSTALL_append = " ia6270-vid"
IMAGE_INSTALL_append = " serd"

