SRC_URI += "file://user_2017-12-07-19-42-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

